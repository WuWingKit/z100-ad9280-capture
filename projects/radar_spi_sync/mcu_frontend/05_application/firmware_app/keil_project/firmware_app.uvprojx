# Keil uVision project firmware_app.uvprojx, settings and files
target radar_sync_mcu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: radar_sync_mcu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M3,ARM_MATH_CM3,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\..\..\00_vendor_hal\adt6101P_comlib;..\..\..\00_vendor_hal\adt6101P_hardwarelib\inc;..\..\..\00_vendor_hal\cmsis;..\..\..\00_vendor_hal\cmsis\CMSIS\Include;..\..\..\00_vendor_hal\cmsis\Device\ARM\CMSDK_CM3\Include;..\..\..\00_vendor_hal\cmsis\Device\ARM\CMSDK_CM3\Source\ARM;..\..\..\01_mcu_driver\include;..\..\..\03_peripheral_driver\include;..\..\..\04_internal_library\lab_internal_tools\include;..\source\inc;..\..\..\..\mcu_sync
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group 00_vendor_hal
    ../../../00_vendor_hal/cmsis/: arm_bitreversal2.S
    ../../../00_vendor_hal/cmsis/Device/ARM/CMSDK_CM3/Source/ARM/: startup_CMSDK_CM3.s
    ../../../00_vendor_hal/adt6101P_hardwarelib/src/: adt6101P_adc.c adt6101P_dma.c adt6101P_dsp.c adt6101P_gpio.c adt6101P_i2c.c adt6101P_pmu.c adt6101P_rtc.c adt6101P_rx.c adt6101P_spi.c adt6101P_system.c adt6101P_systick.c adt6101P_timer.c adt6101P_tx.c adt6101P_uart.c adt6101P_watchdog.c adt6101P_windows.c
  group 01_mcu_driver
    ../../../01_mcu_driver/src/: adt2011_gpio_bus.c adt6101p_driver_layer.c adc_bsp.c dma_bsp.c gpio_bsp.c i2c_bsp.c pmu_bsp.c rtc_bsp.c spi_bsp.c sys_bsp.c timer_bsp.c tx_bsp.c uart_bsp.c watchdog_bsp.c lowpower_bsp.c
  group 03_peripheral_driver
    ../../../03_peripheral_driver/src/: adt2011_driver.c
  group 04_internal_library
    ../../../04_internal_library/lab_internal_tools/src/: app_protocol.c
  group 05_application
    ../source/src/: main.c app_main_tasks.c app_hardware_ports.c app_timebase.c adt6101P_inthandler.c adt6101P_init.c scan.c signal_porcess.c app_spi_stream.c
  group SYNC_PING_PONG
    ../source/src/: app_sync_frontend.c
    ../../../../mcu_sync/: radar_sync_pipeline.c
target radar_sync_selftest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: radar_sync_selftest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M3,ARM_MATH_CM3,USE_FULL_ASSERT,RADAR_SYNC_SELFTEST=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
